## server/conf/local.conf
```bitbake
db {
  host = localhost
  port = 9092
  name = "lesn-dev"
  user = "lesn-dev"
  password = "lesn-dev"
}

play.http.secret.key = "changeme"
```
